# Keil uVision project mini.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flight_basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\StartUp;.\Lib\inc;.\Lib\src;.\USER;.\MATH;.\CONFIG;.\HARDWARE;.\HAL;.\USB_hid;.\USB_library
  asm define: SYSCLK_FREQ_72MHz
  asm include: .\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\j_memory.sct
  group USER
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_it.c
    ./USER/: main.c delay.c sys.c scheduler.c INIT.c ALL_DATA.h ALL_DEFINE.h
  group library
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CONFIG
    ./CONFIG/: IIC_SOFTWARE.c USART.c GPIO.c TIM.c ADC.c Spi.c USB_HID.c FLASH.c
  group HARDWARE
    ./HARDWARE/: LED.c nrf24l01.c mpu6050.c flow.c
  group HAL
    ./HAL/: ANO_DT.c remote.c control.c
  group MATH
    ./MATH/: filter.c kalman.c imu.c myMath.c pid.c
  group USB_LIB
    ./USB_library/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_HID
    ./USB_hid/: usb_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group JTask
    ./HAL/: j_core.c j_nav.c j_protocol.c j_sensors.c j_platform.c j_boot.c
    ./HARDWARE/: j_bh1750.c j_bh_i2c.c
