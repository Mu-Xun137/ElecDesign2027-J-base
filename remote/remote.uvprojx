# Keil uVision project remote.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote_basic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,J_REMOTE
  c include: .\USER;.\StartUp;.\Lib\inc;.\Lib\src;.\CONFIG;.\HARDWARE;.\HAL;.\APP;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./StartUp/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
    ./USER/: main.c delay.c sys.c
  group LIB
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CONFIG
    ./CONFIG/: ADC_DMA_Config.c TIM.c Spi.c IIC_SOFTWARE.c USART.c
  group HARDWARE
    ./HARDWARE/: nrf24l01.c
    ./CONFIG/: EEPROM.c
  group HAL
    ./HAL/: remote.c
  group JTask
    ./HAL/: j_protocol.c j_keys.c j_feedback.c j_boot.c
