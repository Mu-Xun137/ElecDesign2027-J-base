LR_FLASH 0x08000000 0x10000 {
 ER_FLASH 0x08000000 0x10000 {
 *.o (RESET,+First)
 *(InRoot$$Sections)
 .ANY (+RO)
 }
 RW_RAM 0x20000000 0x5000 { .ANY (+RW +ZI) }
}
